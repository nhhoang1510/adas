FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://adas-display.cfg"
